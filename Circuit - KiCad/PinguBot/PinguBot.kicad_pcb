# Repository Sartalan/My-PinguBot

File README.md:

# PinguBot

### A simple penguin robot

Penguin robot is not defined yet, his behaviour is not defined and the technology's for build him already are not decided.

The goal in a future is to rewrite this README with the correct information about it so i can build him.
Right now i'm trying to get inspiration for build it, if something like that is posible in first place.

English isn't my native language, so if someone in a future is reading it, i'm so sorry; I'm still improving my English level daily.

For now the branch tree will be like this:

## Branches

+ There will be one branch called "main" which will have all the principal hardware content of the penguin robot, as the 3D design, the electronic circuit and the mathematic theory.
+ There will be one branch called "Web" which will have a web/blog where I'll be writing about the progress of the robot. 

For now that's the way I will work on my project.

# My-PinguBot

## KiCad design Circuit - KiCad/PinguBot/PinguBot.kicad_pcb

Board: 2 copper layers, 96.3 x 104.8 mm, 26 parts (0 on the bottom side), 29 nets.

Parts:
C1: 220μF; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
C2: 10μF; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
C3, C6: 0.1yF; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
C4, C5: 1μf; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
D2: LED; C_Axial_L3.8mm_D2.6mm_P10.00mm_Horizontal
DisplayOled1: Screw_Terminal_01x04; PinSocket_1x04_P2.54mm_Vertical
J1: Jack-DC; BarrelJack_Kycon_KLDX-0202-xC_Horizontal
J2, J3: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
Microphone1: Screw_Terminal_01x02; BORNERA2
MotorOne1: Screw_Terminal_01x02; BORNERA2
MotorTwo1: Screw_Terminal_01x02; BORNERA2
R1: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: POT; BORNERA3
R3: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 1,2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
ServoMotorOne1: Screw_Terminal_01x03; BORNERA3
ServoMotorTwo1: Screw_Terminal_01x03; BORNERA3
Speaker1: Screw_Terminal_01x02; BORNERA2
U1: LM386; DIP-8_W7.62mm_Socket
U3: LM7805_TO220; TO-220-3_Vertical
U4: TSOP45xx; BORNERA3
U5: ESP32_DEVKITC

Connections:
3.3V: DisplayOled1.1, U5.1 (3V3)
5V: C5.1, J2.8, R3.2, R5.1, ServoMotorOne1.3, ServoMotorTwo1.3, U1.6 (V+), U3.3 (VO), U5.19 (5V)
GND: C3.2, C4.2, C5.2, C6.2, D2.1 (K), DisplayOled1.4, J1.2, J2.1, J2.6, J3.1, Microphone1.1, R2.3, ServoMotorOne1.2, ServoMotorTwo1.2, Speaker1.1, U1.2 (-), U1.4 (GND), U3.2 (GND), U4.2 (GND), U5.38 (GND)
IR_DATA: U4.1 (OUT), U5.5 (IO34)
MA1: J3.6, U5.28 (IO17)
MA2: J3.7, U5.27 (IO16)
MB1: J3.4, U5.30 (IO18)
MB2: J3.3, U5.31 (IO19)
MO1: J2.5, MotorOne1.2
MO2: J2.4, MotorOne1.1
MO3: J2.3, MotorTwo1.2
MO4: J2.2, MotorTwo1.1
Microphone ADC: Microphone1.2, U5.8 (IO33)
unnamed: C1.1, R1.1, U1.5
unnamed: C2.1, R4.1
unnamed: C2.2, U1.8 (GAIN)
unnamed: C3.1, R1.2
unnamed: D2.2 (A), R5.2
unnamed: R4.2, U1.1 (GAIN)
unnamed: C1.2, Speaker1.2
unnamed: R2.2, U1.3 (+)
unnamed: C6.1, R3.1, U4.3 (Vs)
SCL_DISPLAY: DisplayOled1.3, U5.36 (IO22)
SDA_DISPLAY: DisplayOled1.2, U5.33 (IO21)
STBY: J3.5, U5.29 (IO5)
S_Motor_OUT_1: ServoMotorTwo1.1, U5.11 (IO27)
S_Motor_OUT_2: ServoMotorOne1.1, U5.12 (IO14)
Speaker DAC: R2.1, U5.9 (IO25)
VIN: C4.1, J1.1, U3.1 (VI)

## Commit log

2025-02-12 Circuit Improvement
2025-05-14 Circuit Improvement | PCB Advanced
2025-05-14 Circuit Improvement | Yay!
2025-11-17 New branch to store the software
2025-11-18 Platformio Code
2025-11-18 Platformio Code Again
